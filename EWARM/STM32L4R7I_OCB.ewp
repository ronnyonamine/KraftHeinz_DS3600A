# IAR project STM32L4R7I_OCB.ewp, settings and files
configuration Oxpecker (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R7AI ST STM32L4R7AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L4R7xx; USE_BPP=16
  ICCARM.IExtraOptions: -DDEBUG_LEVEL1
  ICCARM.CCIncludePath2: ../Core/Inc; ../TouchGFX/App; ../TouchGFX/target/generated; ../TouchGFX/target; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/ST/TouchGFX/framework/include; ../Middlewares/ST/touchgfx/framework/include; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/gui/include; ../Drivers/BSP/Components/ili9342c; ../Drivers/BSP/Components/opt3001; ../Drivers/BSP/Components/w25q256jw; ../Drivers/BSP/Feature
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: STM32L4R7I_OCB.hex
  prebuild: ..\RegParamCollect.exe ..
  postbuild: python post_build.py
  ILINK.IlinkOutputFile: STM32L4R7I_OCB.out
  ILINK.IlinkIcfFile: stm32l4r7xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: STM32L4R7I_OCB.ipcf
  group Application/EWARM
    ./: startup_stm32l4r7xx.s
  group Application/User
    ../Platform/: Oxpecker_platform.a
    ../TouchGFX/gui/lib/: Oxpecker_UI.a
  group Application/User/Core
    ../Drivers/BSP/Feature/: canopyAuto_usercfg.c
    ../Core/Src/: canopyAutoParams.c
    ./: main.c stm32l4xx_it.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Feature
    ../Drivers/BSP/Feature/: user_cfg_wrapper.cpp
  group TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_RobotoCondensed_Bold_20_4bpp_0.cpp Font_RobotoCondensed_Bold_24_4bpp_0.cpp Font_RobotoCondensed_Bold_26_4bpp_0.cpp Font_RobotoCondensed_Bold_26_4bpp_4.cpp Font_RobotoCondensed_Bold_32_4bpp_0.cpp Font_RobotoCondensed_Bold_40_4bpp_0.cpp Font_RobotoCondensed_Bold_48_4bpp_0.cpp Font_RobotoCondensed_Regular_18_4bpp_0.cpp Font_RobotoCondensed_Regular_24_4bpp_0.cpp Font_RobotoCondensed_Regular_26_4bpp_0.cpp Font_RobotoCondensed_Regular_26_4bpp_4.cpp Font_RobotoCondensed_Regular_32_4bpp_0.cpp Font_RobotoCondensed_Regular_32_4bpp_4.cpp Font_RobotoCondensed_Regular_36_4bpp_0.cpp Font_RobotoCondensed_Regular_36_4bpp_4.cpp Font_RobotoMono_Bold_40_4bpp_0.cpp Font_RobotoMono_Bold_40_4bpp_4.cpp Font_RobotoMono_Regular_26_4bpp_0.cpp Font_RobotoMono_Regular_26_4bpp_4.cpp Font_RobotoMono_Regular_32_4bpp_0.cpp Font_RobotoMono_Regular_32_4bpp_4.cpp FontCache.cpp GeneratedFont.cpp Kerning_RobotoCondensed_Bold_20_4bpp.cpp Kerning_RobotoCondensed_Bold_24_4bpp.cpp Kerning_RobotoCondensed_Bold_26_4bpp.cpp Kerning_RobotoCondensed_Bold_32_4bpp.cpp Kerning_RobotoCondensed_Bold_40_4bpp.cpp Kerning_RobotoCondensed_Bold_48_4bpp.cpp Kerning_RobotoCondensed_Regular_18_4bpp.cpp Kerning_RobotoCondensed_Regular_24_4bpp.cpp Kerning_RobotoCondensed_Regular_26_4bpp.cpp Kerning_RobotoCondensed_Regular_32_4bpp.cpp Kerning_RobotoCondensed_Regular_36_4bpp.cpp Kerning_RobotoMono_Bold_40_4bpp.cpp Kerning_RobotoMono_Regular_26_4bpp.cpp Kerning_RobotoMono_Regular_32_4bpp.cpp Table_RobotoCondensed_Bold_20_4bpp.cpp Table_RobotoCondensed_Bold_24_4bpp.cpp Table_RobotoCondensed_Bold_26_4bpp.cpp Table_RobotoCondensed_Bold_32_4bpp.cpp Table_RobotoCondensed_Bold_40_4bpp.cpp Table_RobotoCondensed_Bold_48_4bpp.cpp Table_RobotoCondensed_Regular_18_4bpp.cpp Table_RobotoCondensed_Regular_24_4bpp.cpp Table_RobotoCondensed_Regular_26_4bpp.cpp Table_RobotoCondensed_Regular_32_4bpp.cpp Table_RobotoCondensed_Regular_36_4bpp.cpp Table_RobotoMono_Bold_40_4bpp.cpp Table_RobotoMono_Regular_26_4bpp.cpp Table_RobotoMono_Regular_32_4bpp.cpp
  group TouchGFX/generated/gui_generated
    ../TouchGFX/generated/gui_generated/src/containers/: BarcodeField_LocBase.cpp BarcodeField_MatchBase.cpp BarcodeFieldBase.cpp BluetoothPopupBase.cpp BtnBackBase.cpp CfgMenuToastBase.cpp EntDelimiterFieldBase.cpp EntQTYToutFieldBase.cpp EntStrFieldBase.cpp ImageFocusBase.cpp InventToastBase.cpp InventToastENTBase.cpp InventToastFullBase.cpp InvtListField_LocBase.cpp InvtListFieldBase.cpp KhBottomBarBase.cpp KhEnterOperatorBase.cpp KhErrorBase.cpp KhErrorReasonBase.cpp khLearnBarcodeBase.cpp KhListItemContainerBase.cpp KhListRecordContainerBase.cpp KhMenuBase.cpp KhSendData1Base.cpp KhSendDataBase.cpp KhSplashScreenBase.cpp KhSuccessBase.cpp KhVerifyBarcodeBase.cpp KhViewDataBase.cpp LocationField_LocBase.cpp MatchFieldBase.cpp MatchListFieldBase.cpp MatchListTitleBase.cpp MenuItemBase.cpp NumberField_LocBase.cpp NumberField_MatchBase.cpp NumberFieldBase.cpp RadioBtnBase.cpp SnBackGndBase.cpp StatusBarBase.cpp SuccessCueBase.cpp TextToast_2BlodBase.cpp TextToastBase.cpp UnexpectFieldBase.cpp WildcardedCharEntryFieldBase.cpp WildcardedEntQTYToutFieldBase.cpp WildcardedMenuItemBase.cpp WildcardedRadioBtnBase.cpp
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../TouchGFX/generated/gui_generated/src/khmainscreen_screen/: KHMainScreenViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/snbarcodeprogress_screen/: SnBarcodeProgressViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/sncfgappsubmenu_screen/: SnCfgAppSubMenuViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/sncfgboolparam_screen/: SnCfgBoolParamViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/sncfgcharparam_screen/: SnCfgCharParamViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/sncfgmenu_screen/: SnCfgMenuViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/sncfgnumericparam_screen/: SnCfgNumericParamViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/sncfgradioparam_screen/: SnCfgRadioParamViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/sncfgstringparam_screen/: SnCfgStringParamViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/snfnkeyassign_screen/: SnFnKeyAssignViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/snhomemenu_screen/: SnHomeMenuViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/snimageview_screen/: SnImageViewViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/snoutinmatch_screen/: SnOutInMatchViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/snscanandentloc_screen/: SnScanAndEntLocViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/snscanandentqty_d_screen/: SnScanAndEntQty_DViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/snscanandentqty_screen/: SnScanAndEntQtyViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/snscaninventory_screen/: SnScanInventoryViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/snscreensaver_screen/: SnScreensaverViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/snsplash_screen/: SnSplashViewBase.cpp
  group TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp image_Barcode-active.cpp image_Barcode.cpp image_BatchOn.cpp image_battery-high-eol.cpp image_battery-high.cpp image_battery-high3x.cpp image_battery-high5x.cpp image_battery-low-eol.cpp image_battery-low.cpp image_battery-low3x.cpp image_battery-low5x.cpp image_battery-med-eol.cpp image_battery-med-high-eol.cpp image_battery-med-high.cpp image_battery-med-high3x.cpp image_battery-med-high5x.cpp image_battery-med-low-eol.cpp image_battery-med-low.cpp image_battery-med-low3x.cpp image_battery-med-low5x.cpp image_battery-med.cpp image_battery-med3x.cpp image_battery-med5x.cpp image_Blue_ProgressIndicators_bg_large_progress_indicator_bg_square_0_degrees.cpp image_bluetooth-alt-active.cpp image_bluetooth-alt.cpp image_Check.cpp image_Check_Active.cpp image_Down.cpp image_Exclamation.cpp image_Exclamation_Active.cpp image_FocusRadioOff.cpp image_FocusRadioOn.cpp image_Home.cpp image_Left.cpp image_location-active.cpp image_location-hover.cpp image_location-on.cpp image_mdi-arrow-back-selected.cpp image_mdi-arrow-back.cpp image_Minus.cpp image_Minus_Active.cpp image_nonbattery.cpp image_PreView.cpp image_RadioOff.cpp image_RadioOn.cpp image_Right.cpp image_ShiftBlue.cpp image_ShiftGreen.cpp image_SplashLight.cpp image_Up.cpp image_white_dot_official.cpp
    ../TouchGFX/generated/images/src/__designer/: image_Blue_ProgressIndicators_bg_medium_progress_indicator_bg_square_0_degrees.cpp
  group TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: ConfigParam.cpp FrontendApplication.cpp ZebraApplication.cpp
  group TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: BarcodeField.cpp BarcodeField_Loc.cpp BarcodeField_Match.cpp BluetoothPopup.cpp BtnBack.cpp CfgMenuToast.cpp EntDelimiterField.cpp EntQTYToutField.cpp EntStrField.cpp ImageFocus.cpp InventToast.cpp InventToastENT.cpp InventToastFull.cpp InvtListField.cpp InvtListField_Loc.cpp KhBottomBar.cpp KhEnterOperator.cpp KhError.cpp KhErrorReason.cpp khLearnBarcode.cpp KhListItemContainer.cpp KhListRecordContainer.cpp KhMenu.cpp KhSendData.cpp KhSendData1.cpp KhSplashScreen.cpp KhSuccess.cpp KhVerifyBarcode.cpp KhViewData.cpp LocationField_Loc.cpp MatchField.cpp MatchListField.cpp MatchListTitle.cpp MenuItem.cpp NumberField.cpp NumberField_Loc.cpp NumberField_Match.cpp RadioBtn.cpp SnBackGnd.cpp StatusBar.cpp SuccessCue.cpp TextToast.cpp TextToast_2Blod.cpp UnexpectField.cpp WildcardedCharEntryField.cpp WildcardedEntQTYToutField.cpp WildcardedMenuItem.cpp WildcardedRadioBtn.cpp
  group TouchGFX/gui/khmainscreen_screen
    ../TouchGFX/gui/src/khmainscreen_screen/: KHMainScreenPresenter.cpp KHMainScreenView.cpp
  group TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group TouchGFX/gui/simulator
    ../TouchGFX/gui/src/simulator/: blctrl_sim.c canopyAuto_usercfg.c customAPIcallback_sim.c decodeDataHandler_sim.c ili9342c_sim.c keypad_sim.c KeypadHandlerSim.cpp menuHandler_sim.c SSI_cmd_sim.c strFilter_sim.c user_cfg_sim.c
  group TouchGFX/gui/snbarcodeprogress_screen
    ../TouchGFX/gui/src/snbarcodeprogress_screen/: SnBarcodeProgressPresenter.cpp SnBarcodeProgressView.cpp
  group TouchGFX/gui/sncfgappsubmenu_screen
    ../TouchGFX/gui/src/sncfgappsubmenu_screen/: SnCfgAppSubMenuPresenter.cpp SnCfgAppSubMenuView.cpp
  group TouchGFX/gui/sncfgboolparam_screen
    ../TouchGFX/gui/src/sncfgboolparam_screen/: SnCfgBoolParamPresenter.cpp SnCfgBoolParamView.cpp
  group TouchGFX/gui/sncfgcharparam_screen
    ../TouchGFX/gui/src/sncfgcharparam_screen/: SnCfgCharParamPresenter.cpp SnCfgCharParamView.cpp
  group TouchGFX/gui/sncfgmenu_screen
    ../TouchGFX/gui/src/sncfgmenu_screen/: SnCfgMenuPresenter.cpp SnCfgMenuView.cpp
  group TouchGFX/gui/sncfgnumericparam_screen
    ../TouchGFX/gui/src/sncfgnumericparam_screen/: SnCfgNumericParamPresenter.cpp SnCfgNumericParamView.cpp
  group TouchGFX/gui/sncfgradioparam_screen
    ../TouchGFX/gui/src/sncfgradioparam_screen/: SnCfgRadioParamPresenter.cpp SnCfgRadioParamView.cpp
  group TouchGFX/gui/sncfgstringparam_screen
    ../TouchGFX/gui/src/sncfgstringparam_screen/: SnCfgStringParamPresenter.cpp SnCfgStringParamView.cpp
  group TouchGFX/gui/snfnkeyassign_screen
    ../TouchGFX/gui/src/snfnkeyassign_screen/: FnKeyDefinitions1.cpp FnKeyDefinitions2.cpp FnKeyDefinitions3.cpp SnFnKeyAssignPresenter.cpp SnFnKeyAssignView.cpp
  group TouchGFX/gui/snhomemenu_screen
    ../TouchGFX/gui/src/snhomemenu_screen/: SnHomeMenuPresenter.cpp SnHomeMenuView.cpp
  group TouchGFX/gui/snimageview_screen
    ../TouchGFX/gui/src/snimageview_screen/: SnImageViewPresenter.cpp SnImageViewView.cpp
  group TouchGFX/gui/snoutinmatch_screen
    ../TouchGFX/gui/src/snoutinmatch_screen/: SnOutInMatchPresenter.cpp SnOutInMatchView.cpp
  group TouchGFX/gui/snscanandentloc_screen
    ../TouchGFX/gui/src/snscanandentloc_screen/: SnScanAndEntLocPresenter.cpp SnScanAndEntLocView.cpp
  group TouchGFX/gui/snscanandentqty_d_screen
    ../TouchGFX/gui/src/snscanandentqty_d_screen/: SnScanAndEntQty_DPresenter.cpp SnScanAndEntQty_DView.cpp
  group TouchGFX/gui/snscanandentqty_screen
    ../TouchGFX/gui/src/snscanandentqty_screen/: SnScanAndEntQtyPresenter.cpp SnScanAndEntQtyView.cpp
  group TouchGFX/gui/snscaninventory_screen
    ../TouchGFX/gui/src/snscaninventory_screen/: SnScanInventoryPresenter.cpp SnScanInventoryView.cpp
  group TouchGFX/gui/snscreensaver_screen
    ../TouchGFX/gui/src/snscreensaver_screen/: SnScreensaverPresenter.cpp SnScreensaverView.cpp
  group TouchGFX/gui/snsplash_screen
    ../TouchGFX/gui/src/snsplash_screen/: SnSplashPresenter.cpp SnSplashView.cpp
  group TouchGFX/Lib
    ../Middlewares/ST/touchgfx/lib/core/cortex_m4f/IAR8.x/: touchgfx_core.a
